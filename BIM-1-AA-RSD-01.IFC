Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-RSD.IFC
Time: 2025-09-08T07:24:18
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: C529-1鎖頭主體_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: DC JACK_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: LED (2)
In: Default Storey
PredefinedType: ELEMENT
Name | Material
LED | 0
LED | Steel

# IfcBuildingElementProxy: M5尼帽_Default (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: RSD-感應器護蓋
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD上蓋_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD下蓋_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD外殼N_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD彈簧套管_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD擋板_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: RSD擋板彈簧_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: RSD背板
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: RSD透視窗B_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD鎖頭用5mm螺帽_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD鎖頭用M5彈簧華司
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD鎖頭用舌片_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD鎖頭螺帽_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD電池蓋_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD黑盒子上蓋_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD黑盒子下座_Default
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: RSD黑盒子固定螺絲M4×10 (4)
In: Default Storey
PredefinedType: ELEMENT; Material: 0

# IfcBuildingElementProxy: 給皂機半牙螺絲B (2)
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: 黑盒子動作板_Default
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
